VERSION 5.8 ;
VIA nTSV DEFAULT
  LAYER M0 ;
    RECT -0.012 -0.012 0.012 0.012 ;
  LAYER VSD ;
    RECT -0.009 -0.009 0.009 0.009 ;
  LAYER BPR ;
    RECT -0.021 -0.016 0.021 0.016 ;
END nTSV
END LIBRARY
